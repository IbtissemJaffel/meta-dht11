SRC_URI += "file://dht11.cfg;subdir=git"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

